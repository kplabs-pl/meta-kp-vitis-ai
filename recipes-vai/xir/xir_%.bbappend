FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Newset-GCC-abseil-compatibility.patch;patchdir=../../.."

