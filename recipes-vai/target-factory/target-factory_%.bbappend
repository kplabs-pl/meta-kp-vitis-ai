FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-silence-string-overflow-warning.patch;patchdir=../../.."

