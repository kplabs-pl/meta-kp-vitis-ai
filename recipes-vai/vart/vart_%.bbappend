FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Newset-GCC-compatibility.patch;patchdir=../../.."

